# Keil uVision project RemoteControl.uvprojx, settings and files
target RemoteControl (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RemoteControl +hex
  c flags: Optim=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\APPLICATION\TaskManage;..\SYSTEM\systick;..\HARDWARE\PWR;..\HARDWARE\HANDLE;..\HARDWARE\LCD;..\HARDWARE\CHARGER;..\HARDWARE\KEY;..\PICTURE;..\MPU6050;..\HARDWARE\MOT;..\HARDWARE\DAC;..\HARDWARE\Timer;..\MUSIC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWR/: PWR.c
    ../HARDWARE/HANDLE/: HANDLE.c
    ../HARDWARE/LCD/: lcd.c lcd_init.c
    ../HARDWARE/CHARGER/: CHARGER.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MOT/: MOT.c
    ../HARDWARE/DAC/: DAC.c
    ../HARDWARE/Timer/: Timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/systick/: Systick.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
  group APPLICATION
    ../APPLICATION/TaskManage/: TaskManage.c
  group PICTURE
    ../PICTURE/: Picture.c Photo.c
  group MPU6050
    ../MPU6050/: I2C.c I2C_MPU6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c
  group MUSIC
    ../MUSIC/: yinpin.c
